#Note: Mention Each package in individual line
#      cascaded representation with line breaks are not valid in this file.
IMAGE_INSTALL_append = " peekpoke"
IMAGE_INSTALL_append = " gpio-demo"
IMAGE_INSTALL_append = " opendla"
IMAGE_INSTALL_append = " nvdla-runtime"
IMAGE_INSTALL_append = " libjpeg"
IMAGE_INSTALL_append = " nvdla-test"
IMAGE_INSTALL_append = " curl"
